
#include "SpritesManager.h"

const uint16_t SpritesManager::WIDTH_CARD = 9;
const uint16_t SpritesManager::HEIGHT_CARD = 14;

bool SpritesManager::heartInitialized = false;
Image SpritesManager::heart;
bool SpritesManager::diamondInitialized = false;
Image SpritesManager::diamond;
bool SpritesManager::cloverInitialized = false;
Image SpritesManager::clover;
bool SpritesManager::spadeInitialized = false;
Image SpritesManager::spade;

Image& SpritesManager::getHeart() {
  if(! SpritesManager::heartInitialized) {
    static const uint16_t heartData[] = {
      9,      // frame width
      14,     // frame height
      1,      // number of frames
      0,      // animation speed
      0xf81f, // transparent color
      0,      // RGB565 color mode
      // frame 1/1
      0x044a, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0x044a, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xd8e4, 0xffff, 0xd8e4, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xd8e4, 0xd8e4, 0xd8e4, 0xd8e4, 0xd8e4, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xd8e4, 0xd8e4, 0xd8e4, 0xd8e4, 0xd8e4, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xd8e4, 0xd8e4, 0xd8e4, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xd8e4, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0x044a, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0x044a
    };
    SpritesManager::heart = Image(heartData);
    SpritesManager::heartInitialized = true;
  }
  return SpritesManager::heart;
}

Image& SpritesManager::getDiamond() {
  if(! SpritesManager::diamondInitialized) {
    static const uint16_t diamondData[] = {
      9,      // frame width
      14,     // frame height
      1,      // number of frames
      0,      // animation speed
      0xf81f, // transparent color
      0,      // RGB565 color mode
      // frame 1/1
      0x044a, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0x044a, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xd8e4, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xd8e4, 0xd8e4, 0xd8e4, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xd8e4, 0xd8e4, 0xffff, 0xd8e4, 0xd8e4, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xd8e4, 0xd8e4, 0xd8e4, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xd8e4, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0x044a, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0x044a
    };
    SpritesManager::diamond = Image(diamondData);
    SpritesManager::diamondInitialized = true;
  }
  return SpritesManager::diamond;
}

Image& SpritesManager::getClover() {
  if(! SpritesManager::cloverInitialized) {
    static const uint16_t cloverData[] = {
      9,      // frame width
      14,     // frame height
      1,      // number of frames
      0,      // animation speed
      0xf81f, // transparent color
      0,      // RGB565 color mode
      // frame 1/1
      0x044a, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0x044a, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0x0000, 0x0000, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0x0000, 0xffff, 0x0000, 0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 
      0xffff, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xffff, 0xffff, 0xffff, 
      0xffff, 0x0000, 0xffff, 0x0000, 0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0x044a, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0x044a
    };
    SpritesManager::clover = Image(cloverData);
    SpritesManager::cloverInitialized = true;
  }
  return SpritesManager::clover;
}

Image& SpritesManager::getSpade() {
  if(! SpritesManager::spadeInitialized) {
    static const uint16_t spadeData[] = {
      9,      // frame width
      14,     // frame height
      1,      // number of frames
      0,      // animation speed
      0xf81f, // transparent color
      0,      // RGB565 color mode
      // frame 1/1
      0x044a, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0x044a, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0x0000, 0x0000, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xffff, 0xffff, 0xffff, 
      0xffff, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
      0x044a, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0x044a
    };
    SpritesManager::spade = Image(spadeData);
    SpritesManager::spadeInitialized = true;
  }
  return SpritesManager::spade;
}
